# Keil uVision project ble_app_multilink_central.uvproj, settings and files
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_mega +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include\app_common;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include\ble;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include\ble\device_manager;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include\ble\ble_services;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include\s120;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\include\boards;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\include\sd_common;C:\Development\BLE\NORDIC_DEV_6\nrf51822_sdk\Include\sdk
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Startup Code
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/templates/arm/: arm_startup_nrf51.s
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: ble_uart_c.c blinkm.c debug.c SwitchbotNordic.c time_utils.c twi_master.c uart_comm2.c device_manager_central.c
  group Services
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/ble/ble_services/: ble_hrs_c.c
  group Libraries
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/app_common/: pstorage.c app_gpiote.c app_trace.c
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/ble/: ble_db_discovery.c ble_debug_assert_handler.c
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/sd_common/: softdevice_handler.c
    C:/Development/BLE/NORDIC_DEV_6/nrf51822_sdk/Source/nrf_delay/: nrf_delay.c
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_multilink_central +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER S120_SUPPORT_REQD BOARD_NRF6310 BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s120;..\..\..\..\..\include\boards;..\..\..\..\..\include\sd_common;..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
